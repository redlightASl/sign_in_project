# Keil uVision project yoloface.uvprojx, settings and files
target yoloface (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: yoloface +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,TFT96,W25Qxx
  c include: ../Core/Inc;            ../Middlewares/ST/AI/Inc;            ../X-CUBE-AI/App;            ../Drivers/STM32H7xx_HAL_Driver/Inc;            ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;            ../Drivers/CMSIS/Include;            ..\Drivers\BSP\Camera;            ..\Drivers\BSP\ST7735;            ..\Drivers\NN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dcmi.c dma.c i2c.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: yoloface_generate_report.txt
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/ST7735
    ../Drivers/BSP/ST7735/: lcd.c logo_128_160.c logo_160_80.c st7735.c st7735_reg.c
  group Drivers/Camera
    ../Drivers/BSP/Camera/: camera.c ov2640.c ov2640_regs.c ov5640.c ov5640_regs.c ov7670.c ov7670_regs.c ov7725.c ov7725_regs.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime710_CM7_Keil.lib
  group Drivers/NN
    ../Drivers/NN/: yoloface_nn.c
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: yoloface.c yoloface_data.c
software components: CMSIS:CORE 5.5.0
